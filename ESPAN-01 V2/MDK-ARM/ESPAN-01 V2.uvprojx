# Keil uVision project ESPAN-01 V2.uvprojx, settings and files
target ESPAN-01 V2 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F070CBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: ESPAN-01 V2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F070xB
  c include: ../Inc;              ../Drivers/STM32F0xx_HAL_Driver/Inc;              ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;              ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;              ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;              ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;              ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f070xb.s
  group Application/User
    ../Src/: main.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_usb.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
